# file: SelfCoded.ioc
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Mcu.Family=STM32F3
Mcu.Name=STM32F303V(B-C)Tx
Mcu.Package=LQFP100
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
ProjectManager.HeapSize=0x200
ProjectManager.StackSize=0x400
ProjectManager.TargetToolchain=STM32CubeIDE
RCC.AHBFreq_Value=8000000
RCC.APB1Freq_Value=8000000
RCC.APB2Freq_Value=8000000
RCC.CortexFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.HSI_VALUE=8000000
RCC.LSE_VALUE=32768
RCC.SYSCLKFreq_VALUE=8000000
board=custom

// file: Core/Src/main.c
/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2022 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
#include "main.h"

/* USER CODE BEGIN PM */

static void enable_blue_button() {
	  __HAL_RCC_GPIOA_CLK_ENABLE();
	  GPIO_InitTypeDef GPIO_InitStruct = {0};
	  GPIO_InitStruct.Pin = GPIO_PIN_0;
	  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
	  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
	  GPIO_InitStruct.Pull = GPIO_PULLDOWN;
	  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);
}

static void enable_on_board_led() {
	  __HAL_RCC_GPIOE_CLK_ENABLE();
	  GPIO_InitTypeDef GPIO_InitStruct = {0};
	  GPIO_InitStruct.Pin = GPIO_PIN_8 | GPIO_PIN_9 | GPIO_PIN_10 | GPIO_PIN_11 | GPIO_PIN_12 | GPIO_PIN_13 | GPIO_PIN_14 | GPIO_PIN_15;
	  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
	  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
	  GPIO_InitStruct.Pull = GPIO_PULLDOWN;
	  HAL_GPIO_Init(GPIOE, &GPIO_InitStruct);
}

static void enable_ou_led() {
	  __HAL_RCC_GPIOC_CLK_ENABLE();
	  GPIO_InitTypeDef GPIO_InitStruct = {0};
	  GPIO_InitStruct.Pin = GPIO_PIN_0 | GPIO_PIN_1;
	  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
	  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
	  GPIO_InitStruct.Pull = GPIO_PULLDOWN;
	  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);
}

static void enable_seven_segment() {
	  __HAL_RCC_GPIOD_CLK_ENABLE();
	  GPIO_InitTypeDef GPIO_InitStruct = {0};
	  GPIO_InitStruct.Pin = GPIO_PIN_8 | GPIO_PIN_9 | GPIO_PIN_10 | GPIO_PIN_11 | GPIO_PIN_12 | GPIO_PIN_13 | GPIO_PIN_14;
	  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
	  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_HIGH;
	  GPIO_InitStruct.Pull = GPIO_PULLDOWN;
	  HAL_GPIO_Init(GPIOD, &GPIO_InitStruct);
}

typedef struct {
    uint16_t A;
    uint16_t B;
    uint16_t C;
    uint16_t D;
    uint16_t E;
    uint16_t F;
    uint16_t G;
} SevenSegemnt;

SevenSegemnt initSevenSegment(
        uint16_t A,
        uint16_t B,
        uint16_t C,
        uint16_t D,
        uint16_t E,
        uint16_t F,
        uint16_t G
) {
    SevenSegemnt sevenSegemnt;
    sevenSegemnt.A = A;
    sevenSegemnt.B = B;
    sevenSegemnt.C = C;
    sevenSegemnt.D = D;
    sevenSegemnt.E = E;
    sevenSegemnt.F = F;
    sevenSegemnt.G = G;
    return sevenSegemnt;
}

static SevenSegemnt ZeroNumberSevenSegment = {1,1,1,1,1,1,0};
static SevenSegemnt OneNumberSevenSegment = {0,1,1,0,0,0,0};
static SevenSegemnt TwoNumberSevenSegment = {1,1,0,1,1,0,1};
static SevenSegemnt ThreeNumberSevenSegment = {1,1,1,1,0,0,1};
static SevenSegemnt FourNumberSevenSegment = {0,1,1,0,0,1,1};
static SevenSegemnt FiveNumberSevenSegment = {1,0,1,1,0,1,1};
static SevenSegemnt SixNumberSevenSegment = {1,0,1,1,1,1,1};
static SevenSegemnt SevenNumberSevenSegment = {1,1,1,0,0,0,0};
static SevenSegemnt EightNumberSevenSegment = {1,1,1,1,1,1,1};
static SevenSegemnt NineNumberSevenSegment = {1,1,1,0,0,1,1};

/* USER CODE END PM */

//I2C_HandleTypeDef hi2c1;

//void SystemClock_Config(void);
//static void MX_GPIO_Init(void);
//static void MX_I2C1_Init(void);
//static void MX_SPI1_Init(void);
//static void MX_USB_PCD_Init(void);

int main(void)
{

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */

  enable_blue_button();
  enable_on_board_led();
  enable_ou_led();
  enable_seven_segment();
//  MX_I2C1_Init();
//  MX_SPI1_Init();
//  MX_USB_PCD_Init();
  /* USER CODE BEGIN 2 */

  int counter = 0;
  int onBoardLEDNumber = 0;

  /* USER CODE END 2 */

  /* Infinite loop */
  while (1)
  {

    /* USER CODE BEGIN 3 */

	  if (HAL_GPIO_ReadPin(GPIOA, GPIO_PIN_0) == 1) {

		  counter++;
		  if (counter == 10) {
			  onBoardLEDNumber++;
			  counter = 0;

			  if (onBoardLEDNumber > 6) {
				  onBoardLEDNumber = 0;
			  }

			  if (onBoardLEDNumber == 0) {
				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_8, 0);
				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_9, 1);
			  } else if (onBoardLEDNumber == 1) {
				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_9, 0);
				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_10, 1);
			  }
			  else if (onBoardLEDNumber == 2) {
			  				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_10, 0);
			  				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_11, 1);
			  			  }
			  else if (onBoardLEDNumber == 3) {
			  			  				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_11, 0);
			  			  				  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_12, 1);
			  			  			  }
			  else if (onBoardLEDNumber == 4) {
			  			  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_12, 0);
			  			 HAL_GPIO_WritePin(GPIOE,GPIO_PIN_13, 1);
			  			  			  			  }
			  else if (onBoardLEDNumber == 5) {
			  			  			  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_13, 0);
			  			  			 HAL_GPIO_WritePin(GPIOE,GPIO_PIN_14, 1);
			  			  			  			  			  }
			  else if (onBoardLEDNumber == 6) {
			  			  			  HAL_GPIO_WritePin(GPIOE,GPIO_PIN_14, 0);
			  			  			 HAL_GPIO_WritePin(GPIOE,GPIO_PIN_15, 1);
			  			  			  			  			  }

		  }

		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_8, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_9, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_10, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_11, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_12, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_13, 0);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_14, 0);

		  HAL_Delay(300);
		  SevenSegemnt sev = ZeroNumberSevenSegment;

		  HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 0);
		  HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 0);

		  if (counter == 0) {
			  sev = ZeroNumberSevenSegment;
			  HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 1);
		  }
		  else if (counter == 1) {
			  sev = OneNumberSevenSegment;
			  HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 1);
		  }
		  else if (counter == 2) {
		  	  sev = TwoNumberSevenSegment;
		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 1);
		  }
		  else if (counter == 3) {
		  	  sev = ThreeNumberSevenSegment;
		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 1);
		  }
		  else if (counter == 4) {
		  		  	  sev = FourNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 1);
		  		  }
		  else if (counter == 5) {
		  		  	  sev = FiveNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 1);
		  		  }
		  else if (counter == 6) {
		  		  	  sev = SixNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 1);
		  		  }
		  else if (counter == 7) {
		  		  	  sev = SevenNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 1);
		  		  }
		  else if (counter == 8) {
		  		  	  sev = EightNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_0, 1);
		  		  }
		  else if (counter == 9) {
		  		  	  sev = NineNumberSevenSegment;
		  		  	HAL_GPIO_WritePin(GPIOC,GPIO_PIN_1, 1);
		  		  }

		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_8, sev.A);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_9, sev.B);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_10, sev.C);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_11, sev.D);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_12, sev.E);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_13, sev.F);
		  HAL_GPIO_WritePin(GPIOD,GPIO_PIN_14, sev.G);

	  }

  }
  /* USER CODE END 3 */
}

void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};
  RCC_PeriphCLKInitTypeDef PeriphClkInit = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI|RCC_OSCILLATORTYPE_HSE;
  RCC_OscInitStruct.HSEState = RCC_HSE_BYPASS;
  RCC_OscInitStruct.HSEPredivValue = RCC_HSE_PREDIV_DIV1;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = RCC_HSICALIBRATION_DEFAULT;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSE;
  RCC_OscInitStruct.PLL.PLLMUL = RCC_PLL_MUL6;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1|RCC_CLOCKTYPE_PCLK2;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_1) != HAL_OK)
  {
    Error_Handler();
  }
  PeriphClkInit.PeriphClockSelection = RCC_PERIPHCLK_USB|RCC_PERIPHCLK_I2C1;
  PeriphClkInit.I2c1ClockSelection = RCC_I2C1CLKSOURCE_HSI;
  PeriphClkInit.USBClockSelection = RCC_USBCLKSOURCE_PLL;
  if (HAL_RCCEx_PeriphCLKConfig(&PeriphClkInit) != HAL_OK)
  {
    Error_Handler();
  }
}

void Error_Handler(void)
{
  __disable_irq();
  while (1)
  {
  }
}
